#
PACKAGECONFIG += "gstreamer alsa examples"
